options:
  parameters:
    author: user
    category: '[JAERO]'
    description: Takes input of One Channelizer Channel Performs DSP and Sends out 16-bit Audio
    generate_options: hb
    id: pfb_out_to_jaero_zmq
    output_language: python
    title: PFB Out to 16-bit Audio Shorts
  states: {}

blocks:
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: (usb_bw)*0.95
    low_cutoff_freq: (usb_bw)*0.05
    samp_rate: pfb_rs_rate
    type: complex_band_pass
    width: (usb_bw)*0.05
    win: window.WIN_HAMMING
  states: {}
- name: frac_bw_0
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: nphases_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pfb_rs_rate
  id: variable
  parameters:
    value: audio_rate
  states: {}
- name: pfb_rs_ratio
  id: variable
  parameters:
    value: pfb_rs_rate/pfb_out_rate
  states: {}
- name: pfb_rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases_0, nphases_0, frac_bw_0, 0.5-frac_bw_0)
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Rate
    type: eng_float
    value: 48e3
  states: {}
- name: audio_volume
  id: parameter
  parameters:
    label: Audio Volume Level
    type: eng_float
    value: '100.0'
  states: {}
- name: blocks_complex_to_real_0_0_1_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_short_0_4_1_0
  id: blocks_float_to_short
  parameters:
    scale: short_scaling
  states: {}
- name: blocks_freqshift_cc_0_0_1_0
  id: blocks_freqshift_cc
  parameters:
    freq: usb_bw/2
    sample_rate: pfb_rs_rate
  states: {}
- name: blocks_multiply_const_vxx_0_4_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: fft_filter_xxx_0_1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: ccc
  states: {}
- name: interp
  id: parameter
  parameters:
    label: Interpolation
    type: intx
    value: '2'
  states: {state: disabled}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: short
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out2
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: pfb_rs_ratio
    taps: pfb_rs_taps
    type: ccf
  states: {}
- name: pfb_out_rate
  id: parameter
  parameters:
    label: Input Samp Rate
    type: eng_float
    value: 15e3
  states: {}
- name: rational_resampler_xxx_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interp
    type: ccc
  states: {state: disabled}
- name: short_scaling
  id: parameter
  parameters:
    label: Float to Short Scaling
    type: intx
    value: '32768'
  states: {}
- name: usb_bw
  id: parameter
  parameters:
    label: USB BW
    type: eng_float
    value: 24e3
  states: {}

connections:
- [blocks_complex_to_real_0_0_1_0, '0', blocks_multiply_const_vxx_0_4_1_0, '0']
- [blocks_float_to_short_0_4_1_0, '0', pad_sink_0, '0']
- [blocks_freqshift_cc_0_0_1_0, '0', fft_filter_xxx_0_1, '0']
- [blocks_multiply_const_vxx_0_4_1_0, '0', blocks_float_to_short_0_4_1_0, '0']
- [fft_filter_xxx_0_1, '0', blocks_complex_to_real_0_0_1_0, '0']
- [fft_filter_xxx_0_1, '0', pad_sink_0_0, '0']
- [pad_source_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pad_source_0, '0', rational_resampler_xxx_0_0_1_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_freqshift_cc_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_1_0, '0', blocks_freqshift_cc_0_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0-rc1
