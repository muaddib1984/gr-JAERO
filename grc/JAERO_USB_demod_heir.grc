options:
  parameters:
    author: muaddib
    category: '[JAERO]'
    generate_options: hb
    id: JAERO_USB_demod
    output_language: python
    title: JAERO USB Demodulator
  states: {}

blocks:
- name: LO_freq
  id: parameter
  parameters:
    label: LO Frequency
    short_id: L
    type: eng_float
    value: '900'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: LO_freq
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: LO_freq
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_lpf
  id: parameter
  parameters:
    label: Audio LPF
    short_id: A
    type: eng_float
    value: '24000'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio Rate
    short_id: L
    type: eng_float
    value: '48000'
  states: {}
- name: bfo_real
  id: pad_sink
  parameters:
    label: BFO Real
    type: float
  states: {}
- name: bfo_real_0
  id: pad_sink
  parameters:
    label: BFO Imag
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '32768'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ssb
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '125'
    win: firdes.WIN_HAMMING
  states: {}
- name: hilbert_fc_0_0
  id: hilbert_fc
  parameters:
    comment: |-
      Real part is not phase shifted, 
      only delayed to match Imaginary
    num_taps: '125'
    win: firdes.WIN_HAMMING
  states: {}
- name: last_lpf
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_freq
    decim: '1'
    gain: lpf_gain
    samp_rate: audio_rate
    type: fir_filter_fff
    width: (audio_rate/2)*.2
    win: firdes.WIN_HAMMING
  states: {}
- name: last_lpf_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf_freq
    decim: '1'
    gain: lpf_gain
    samp_rate: audio_rate
    type: fir_filter_fff
    width: (audio_rate/2)*.2
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: audio_lpf
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: lpf_freq
  id: parameter
  parameters:
    label: LPF Frequency
    short_id: F
    type: eng_float
    value: '24000'
  states: {}
- name: lpf_gain
  id: parameter
  parameters:
    label: LPF Gain
    short_id: G
    type: eng_float
    value: '1.0'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      ----------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      AUDIO STAGE
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      ----------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
      SSB STAGE
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: audio_16bit_out
    type: short
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: audio_floats_out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: real
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: imag
    type: float
  states: {}
- name: ssb
  id: parameter
  parameters:
    label: 1=LSB -1=USB
    short_id: S
    type: eng_float
    value: '-1'
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}
- name: volume
  id: parameter
  parameters:
    label: OUTPUT VOLUME
    short_id: V
    type: eng_float
    value: '0.9'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_1, '0', virtual_sink_0_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_float_to_short_0, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_0, '0', last_lpf, '0']
- [blocks_multiply_xx_1, '0', last_lpf_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_imag_0, '0']
- [hilbert_fc_0_0, '0', blocks_complex_to_real_0_0, '0']
- [last_lpf, '0', bfo_real, '0']
- [last_lpf, '0', hilbert_fc_0_0, '0']
- [last_lpf_0, '0', bfo_real_0, '0']
- [last_lpf_0, '0', hilbert_fc_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '1']
- [pad_source_0_0, '0', blocks_multiply_xx_1, '0']
- [virtual_source_0_1, '0', low_pass_filter_0_0, '0']

metadata:
  file_format: 1
