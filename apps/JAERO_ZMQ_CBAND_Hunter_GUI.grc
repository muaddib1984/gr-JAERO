options:
  parameters:
    author: muaddib
    description: Visual Display for Spotting CBAND AERO Burst Signals
    generate_options: qt_gui
    id: JAERO_ZMQ_CBAND_Hunter_GUI
    output_language: python
    title: CBAND Hunter GUI
  states: {}

blocks:
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:12,0,1,5
    label: Audio Signal Volume
    start: '0.1'
    step: '0.1'
    stop: '1000'
    value: '100.0'
  states: {state: disabled}
- name: bin_size
  id: variable
  parameters:
    value: (samp_rate/fft_len)
  states: {}
- name: channel_or_subband
  id: variable_qtgui_chooser
  parameters:
    label: Channel or Subband
    labels: '["channel","subband"]'
    num_opts: '0'
    options: '[i for i in range(2)]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: conf_section
  id: variable
  parameters:
    value: '"subband" if channel_or_subband == 1 else "channel"'
  states: {state: disabled}
- name: conf_section
  id: variable
  parameters:
    value: '"subband"'
  states: {state: disabled}
- name: dec0
  id: variable
  parameters:
    value: n_chans
  states: {}
- name: dec0_rate
  id: variable
  parameters:
    value: xlate_rate/dec0
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: frac_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Center Frequency of 
      your Capture File
    value: 1534e6
  states: {}
- name: freq_write
  id: variable
  parameters:
    comment: |-
      default variable 
      with value needed
    value: '0'
  states: {}
- name: half_band
  id: variable
  parameters:
    value: int(fft_len//2)
  states: {}
- name: half_subband
  id: variable
  parameters:
    value: int(fft_len//n_chans//2)
  states: {}
- name: n_chans
  id: variable
  parameters:
    value: '9'
  states: {}
- name: n_subbands
  id: variable
  parameters:
    value: '5'
  states: {}
- name: nphases
  id: variable
  parameters:
    value: '32'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: pass_band_bins
  id: variable
  parameters:
    value: int(((dec0_rate/2)*0.1)/(samp_rate/fft_len))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample Rate of your Capture File
    value: 1.92e6
  states: {state: disabled}
- name: samp_rate
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: sample_rate
    section: sdr_params
    type: real
    value: 2.16e6
    writeback: samp_rate
  states: {}
- name: short_scaling
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:12,5,1,5
    label: JAERO DIGITAL VOLUME
    rangeType: int
    start: '1'
    step: '1'
    stop: '65536'
    value: '32768'
  states: {state: disabled}
- name: subband
  id: variable
  parameters:
    value: int(fft_len/n_chans)
  states: {}
- name: subband0_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband0_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband_positions[1]*bin_size
    writeback: subband_0
  states: {}
- name: subband0_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,0,1,2
    label: subband0_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: int((subband0_offset-(-xlate_rate/2))/bin_size)
  states: {}
- name: subband1_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband1_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband_positions[3]*bin_size
    writeback: subband_1
  states: {}
- name: subband1_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,2,1,2
    label: subband1_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: int((subband1_offset-(-xlate_rate/2))/bin_size)
  states: {}
- name: subband2_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband2_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband_positions[5]*bin_size
    writeback: subband_2
  states: {}
- name: subband2_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,4,1,2
    label: subband2_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: int((subband2_offset-(-xlate_rate/2))/bin_size)
  states: {}
- name: subband2_pos_val
  id: variable
  parameters:
    value: (-xlate_rate/2)+subband2_pos*bin_size
  states: {state: disabled}
- name: subband3_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband3_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband_positions[7]*bin_size
    writeback: subband_3
  states: {}
- name: subband3_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,6,1,2
    label: subband3_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: int((subband3_offset-(-xlate_rate/2))/bin_size)
  states: {}
- name: subband4_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband4_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband_positions[9]*bin_size
    writeback: subband_4
  states: {}
- name: subband4_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,8,1,2
    label: subband4_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: int((subband4_offset-(-xlate_rate/2))/bin_size)
  states: {}
- name: subband_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,0,1,1
    type: real
    value: (-xlate_rate/2)+subband0_pos*bin_size
  states: {}
- name: subband_1
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,2,1,1
    type: real
    value: (-xlate_rate/2)+subband1_pos*bin_size
  states: {}
- name: subband_2
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,4,1,1
    type: real
    value: (-xlate_rate/2)+subband2_pos*bin_size
  states: {}
- name: subband_3
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,6,1,1
    type: real
    value: (-xlate_rate/2)+subband3_pos*bin_size
  states: {}
- name: subband_4
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,8,1,1
    type: real
    value: (-xlate_rate/2)+subband4_pos*bin_size
  states: {}
- name: subband_positions
  id: variable
  parameters:
    value: '[i for i in range(0,fft_len,half_subband*(n_chans//5))]'
  states: {}
- name: subband_write
  id: variable
  parameters:
    value: '"subband_"+str(write_subband_select)'
  states: {state: disabled}
- name: subband_write_1
  id: variable
  parameters:
    value: '"subband_"+str(write_subband_select)'
  states: {state: disabled}
- name: subband_write_2
  id: variable
  parameters:
    value: '"subband_"+str(write_subband_select)'
  states: {state: disabled}
- name: subband_write_3
  id: variable
  parameters:
    value: '"subband_"+str(write_subband_select)'
  states: {state: disabled}
- name: subband_write_4
  id: variable
  parameters:
    value: '"subband_"+str(write_subband_select)'
  states: {state: disabled}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: write_freq_select_var
    section: conf_section
    type: real
    value: '0'
    writeback: freq_write
  states: {state: disabled}
- name: waterfall_max
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,0,1,5
    label: waterfall max
    start: '-200'
    step: '1'
    stop: '0'
    value: '-78'
  states: {}
- name: waterfall_min
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,5,1,5
    label: waterfall min
    start: '-200'
    step: '1'
    stop: '0'
    value: '-90'
  states: {}
- name: write_freq_select
  id: variable_qtgui_chooser
  parameters:
    label: Write Frequency to Conf
    labels: '[str(i) for i in range(40)]'
    num_opts: '0'
    options: '[i for i in range(40)]'
    type: real
    value: '0'
  states: {state: disabled}
- name: write_freq_select_var
  id: variable
  parameters:
    value: '"freq_"+str(write_freq_select) if channel_or_subband==0 else subband3_pos'
  states: {state: disabled}
- name: write_freq_select_var
  id: variable
  parameters:
    value: '"freq_"+str(write_freq_select)'
  states: {state: disabled}
- name: write_subband_select
  id: variable_qtgui_chooser
  parameters:
    label: Write Subband Freq to Conf
    labels: '[str(i) for i in range(n_subbands)]'
    num_opts: '0'
    options: '[i for i in range(n_subbands)]'
    type: real
    value: '0'
  states: {state: disabled}
- name: xlate_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_add_xx_0_0_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: fft_len//24
    max_iter: fft_len//24
    scale: 1/(fft_len/24)
    type: float
    vlen: fft_len
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_write
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-76'
    n: '20'
    vlen: fft_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband0_pos-1)+[2000]+[-1000]*(half_band*2-subband0_pos)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband0_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband0_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband1_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband1_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband2_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband2_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband3_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband3_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_0_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband4_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband4_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband0_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband0_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband1_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband1_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_1_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband2_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband2_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_1_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband3_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband3_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_1_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband4_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband4_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband1_pos-1)+[2000]+[-1000]*(half_band*2-subband1_pos)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_2_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband2_pos-1)+[2000]+[-1000]*(half_band*2-subband2_pos)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_2_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband3_pos-1)+[2000]+[-1000]*(half_band*2-subband3_pos)'
    vlen: fft_len
  states: {}
- name: blocks_vector_source_x_0_2_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband4_pos-1)+[2000]+[-1000]*(half_band*2-subband4_pos)'
    vlen: fft_len
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    color1: '"green"'
    color2: '"cyan"'
    color3: '"magenta"'
    color4: '"dark red"'
    color5: '"dark green"'
    color6: '"dark blue"'
    gui_hint: tabs@0:0,0,1,10
    legend: 'False'
    nconnections: '6'
    update_time: '0.01'
    vlen: fft_len
    x_axis_label: '""'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '""'
    ymax: '-60'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: '16384'
    gui_hint: tabs@0:2,0,1,10
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from pathlib import Path
      fle = Path('/tmp/cband_hunter_config.conf')
      fle.touch(exist_ok=True)
    section: main_after_init
  states: {}
- name: sub_wtf0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,0,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband0"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: sub_wtf1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,2,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband1"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: sub_wtf2
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,4,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband2"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: sub_wtf3
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,6,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband3"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: sub_wtf4
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,8,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband4"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,12,10
    label0: RF Spectrum
    num_tabs: '1'
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_subband0_pos
    port: '9000'
    variable: subband0_pos
  states: {}
- name: xmlrpc_client_0_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_subband1_pos
    port: '9000'
    variable: subband1_pos
  states: {}
- name: xmlrpc_client_0_1
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_subband2_pos
    port: '9000'
    variable: subband2_pos
  states: {}
- name: xmlrpc_client_0_2
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_subband3_pos
    port: '9000'
    variable: subband3_pos
  states: {}
- name: xmlrpc_client_0_3
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_subband4_pos
    port: '9000'
    variable: subband4_pos
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5002
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5001
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5003
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_2
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5005
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_3
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5004
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_vector_sink_f_0, '5']
- [blocks_add_xx_0_0, '0', qtgui_vector_sink_f_0, '4']
- [blocks_add_xx_0_0_0, '0', qtgui_vector_sink_f_0, '3']
- [blocks_add_xx_0_0_0_0, '0', qtgui_vector_sink_f_0, '2']
- [blocks_add_xx_0_0_0_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_add_xx_0_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_add_xx_0_0_0_0_0, '1']
- [blocks_vector_source_x_0_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [blocks_vector_source_x_0_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_vector_source_x_0_0_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_vector_source_x_0_0_0_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_vector_source_x_0_1, '0', blocks_add_xx_0_0_0_0_0, '2']
- [blocks_vector_source_x_0_1_0, '0', blocks_add_xx_0_0_0_0, '2']
- [blocks_vector_source_x_0_1_0_0, '0', blocks_add_xx_0_0_0, '2']
- [blocks_vector_source_x_0_1_0_0_0, '0', blocks_add_xx_0_0, '2']
- [blocks_vector_source_x_0_1_0_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_vector_source_x_0_2, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_vector_source_x_0_2_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_vector_source_x_0_2_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_vector_source_x_0_2_0_0_0, '0', blocks_add_xx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [qtgui_waterfall_sink_x_0, freq, blocks_msgpair_to_var_0, inpair]
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_source_0_0, '0', sub_wtf1, '0']
- [zeromq_sub_source_0_0_0, '0', sub_wtf0, '0']
- [zeromq_sub_source_0_1, '0', sub_wtf2, '0']
- [zeromq_sub_source_0_2, '0', sub_wtf4, '0']
- [zeromq_sub_source_0_3, '0', sub_wtf3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0-rc1
