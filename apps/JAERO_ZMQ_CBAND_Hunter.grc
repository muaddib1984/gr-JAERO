options:
  parameters:
    author: muaddib
    description: Upper SIdeband AM Demodulator with ZMQ Output to feed JAERO
    generate_options: qt_gui
    id: JAERO_ZMQ_CBAND_Hunter
    output_language: python
    title: JAERO to ZMQ
  states: {}

blocks:
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:12,0,1,5
    label: Audio Signal Volume
    start: '0.1'
    step: '0.1'
    stop: '1000'
    value: '100.0'
  states: {}
- name: bin_size
  id: variable
  parameters:
    value: (samp_rate/fft_len)
  states: {}
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: (usb_bw)*0.95
    low_cutoff_freq: (usb_bw)*0.05
    samp_rate: out_rate
    type: complex_band_pass
    width: (usb_bw)*0.05
    win: window.WIN_HAMMING
  states: {}
- name: channel_or_subband
  id: variable_qtgui_chooser
  parameters:
    label: Channel or Subband
    labels: '["channel","subband"]'
    num_opts: '0'
    options: '[i for i in range(2)]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: conf_section
  id: variable
  parameters:
    value: '"subband" if channel_or_subband == 1 else "channel"'
  states: {state: disabled}
- name: dec0
  id: variable
  parameters:
    value: n_chans
  states: {}
- name: dec0_rate
  id: variable
  parameters:
    value: xlate_rate/dec0
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: frac_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: frac_bw_0
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Center Frequency of 
      your Capture File
    value: 1534e6
  states: {}
- name: freq_write
  id: variable
  parameters:
    comment: |-
      default variable 
      with value needed
    value: '0'
  states: {}
- name: half_band
  id: variable
  parameters:
    value: int(fft_len//2)
  states: {}
- name: half_subband
  id: variable
  parameters:
    value: int(fft_len//n_chans//2)
  states: {}
- name: n_chans
  id: variable
  parameters:
    value: '10'
  states: {}
- name: n_subbands
  id: variable
  parameters:
    value: '5'
  states: {}
- name: nphases
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nphases_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: pass_band_bins
  id: variable
  parameters:
    value: int(((dec0_rate/2)*0.1)/(samp_rate/fft_len))
  states: {}
- name: pfb_dec
  id: variable
  parameters:
    value: round_up_chans
  states: {}
- name: pfb_out_rate
  id: variable
  parameters:
    value: dec0_rate/pfb_dec
  states: {}
- name: pfb_rs_rate
  id: variable
  parameters:
    value: out_rate
  states: {}
- name: pfb_rs_ratio
  id: variable
  parameters:
    value: pfb_rs_rate/pfb_out_rate
  states: {}
- name: pfb_rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases_0, nphases_0, frac_bw_0, 0.5-frac_bw_0)
  states: {state: disabled}
- name: pfb_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: ((usb_bw)/2)*.8
    gain: '1.0'
    samp_rate: dec0_rate
    width: ((usb_bw)/2)*.2
    win: window.WIN_HAMMING
  states: {}
- name: pfbdec0_chan
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tabs@1:2,0,1,3
    labels: '[str(i) for i in range(pfb_dec)]'
    num_opts: '0'
    options: '[i for i in range(pfb_dec)]'
    type: int
    value: '1'
  states: {}
- name: round_up_chans
  id: variable
  parameters:
    value: int((xlate_rate/n_chans)/usb_bw)
  states: {}
- name: rs_rate
  id: variable
  parameters:
    value: round_up_chans*out_rate
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: rs_rate/samp_rate
  states: {}
- name: rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases, nphases, frac_bw, 0.5-frac_bw)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample Rate of your Capture File
    value: 1.92e6
  states: {}
- name: short_scaling
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:12,5,1,5
    label: JAERO DIGITAL VOLUME
    rangeType: int
    start: '1'
    step: '1'
    stop: '65536'
    value: '32768'
  states: {}
- name: subband
  id: variable
  parameters:
    value: int(fft_len/n_chans)
  states: {}
- name: subband0_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband0_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband0_pos*bin_size
    writeback: ''
  states: {}
- name: subband0_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,0,1,2
    label: subband0_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: subband_positions[1]
  states: {state: disabled}
- name: subband0_pos
  id: variable
  parameters:
    value: subband_positions[1]
  states: {}
- name: subband1_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband1_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband1_pos*bin_size
    writeback: ''
  states: {}
- name: subband1_pos
  id: variable
  parameters:
    value: subband_positions[3]-1
  states: {}
- name: subband1_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,2,1,2
    label: subband1_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: subband_positions[3]-1
  states: {state: disabled}
- name: subband2_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband2_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+(subband2_pos*bin_size)
    writeback: ''
  states: {}
- name: subband2_pos
  id: variable
  parameters:
    value: subband_positions[5]
  states: {}
- name: subband2_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,4,1,2
    label: subband2_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: subband_positions[5]
  states: {state: disabled}
- name: subband3_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband3_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband3_pos*bin_size
    writeback: ''
  states: {}
- name: subband3_pos
  id: variable
  parameters:
    value: subband_positions[7]
  states: {}
- name: subband3_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,6,1,2
    label: subband3_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: subband_positions[7]
  states: {state: disabled}
- name: subband4_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband4_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband4_pos*bin_size
    writeback: ''
  states: {}
- name: subband4_pos
  id: variable
  parameters:
    value: subband_positions[9]
  states: {}
- name: subband4_pos
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:8,8,1,2
    label: subband4_pos
    min_len: '10'
    rangeType: int
    start: subband_positions[1]
    step: '1'
    stop: fft_len-half_subband
    value: subband_positions[9]
  states: {state: disabled}
- name: subband_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,0,1,1
    type: real
    value: subband0_pos*bin_size
  states: {}
- name: subband_1
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,2,1,1
    type: real
    value: subband1_pos*bin_size
  states: {}
- name: subband_2
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,4,1,1
    type: real
    value: subband2_offset
  states: {}
- name: subband_3
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,6,1,1
    type: real
    value: subband3_pos*bin_size
  states: {}
- name: subband_4
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,8,1,1
    type: real
    value: subband4_pos*bin_size
  states: {}
- name: subband_positions
  id: variable
  parameters:
    value: '[i for i in range(0,fft_len,half_subband*(n_chans//5))]'
  states: {}
- name: subband_write
  id: variable
  parameters:
    value: '"subband_"+str(write_subband_select)'
  states: {state: disabled}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (dec0_rate/2)*0.9
    gain: '1.0'
    samp_rate: xlate_rate
    width: (dec0_rate/2)*0.1
    win: window.WIN_HAMMING
  states: {}
- name: usb_bw
  id: variable
  parameters:
    value: 24e3
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: write_freq_select_var
    section: conf_section
    type: real
    value: '0'
    writeback: freq_write
  states: {state: disabled}
- name: waterfall_max
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,0,1,5
    label: waterfall max
    start: '-200'
    step: '1'
    stop: '0'
    value: '-78'
  states: {}
- name: waterfall_min
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,5,1,5
    label: waterfall min
    start: '-200'
    step: '1'
    stop: '0'
    value: '-90'
  states: {}
- name: write_freq_select
  id: variable_qtgui_chooser
  parameters:
    label: Write Frequency to Conf
    labels: '[str(i) for i in range(40)]'
    num_opts: '0'
    options: '[i for i in range(40)]'
    type: real
    value: '0'
  states: {state: disabled}
- name: write_freq_select_var
  id: variable
  parameters:
    value: '"freq_"+str(write_freq_select) if channel_or_subband==0 else subband3_pos'
  states: {state: disabled}
- name: write_subband_select
  id: variable_qtgui_chooser
  parameters:
    label: Write Subband Freq to Conf
    labels: '[str(i) for i in range(n_subbands)]'
    num_opts: '0'
    options: '[i for i in range(n_subbands)]'
    type: real
    value: '0'
  states: {state: disabled}
- name: xlate_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: JAERO_zmq_sink_0
  id: JAERO_zmq_sink
  parameters:
    address: tcp://127.0.0.1:6001
    rate: '48000'
    topic: first
  states: {}
- name: JAERO_zmq_sink_0_0
  id: JAERO_zmq_sink
  parameters:
    address: tcp://127.0.0.1:6002
    rate: '48000.0'
    topic: second
  states: {state: disabled}
- name: JAERO_zmq_sink_0_1
  id: JAERO_zmq_sink
  parameters:
    address: tcp://127.0.0.1:6003
    rate: '48000.0'
    topic: third
  states: {state: disabled}
- name: JAERO_zmq_sink_0_2
  id: JAERO_zmq_sink
  parameters:
    address: tcp://127.0.0.1:6004
    rate: '48000.0'
    topic: fourth
  states: {state: disabled}
- name: JAERO_zmq_sink_0_3
  id: JAERO_zmq_sink
  parameters:
    address: tcp://127.0.0.1:6005
    rate: '48000.0'
    topic: fifth
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_add_xx_0_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_add_xx_0_0_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_len
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_2
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_3
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_4
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: short_scaling
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: short_scaling
  states: {state: disabled}
- name: blocks_float_to_short_0_1
  id: blocks_float_to_short
  parameters:
    scale: short_scaling
  states: {state: disabled}
- name: blocks_float_to_short_0_2
  id: blocks_float_to_short
  parameters:
    scale: short_scaling
  states: {state: disabled}
- name: blocks_float_to_short_0_3
  id: blocks_float_to_short
  parameters:
    scale: short_scaling
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: usb_bw/2
    sample_rate: pfb_rs_rate
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: fft_len//24
    max_iter: fft_len//24
    scale: 1/(fft_len/24)
    type: float
    vlen: fft_len
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq_write
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '-76'
    n: '20'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband0_pos-1)+[2000]+[-1000]*(half_band*2-subband0_pos)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband0_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband0_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband1_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband1_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband2_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband2_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband3_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband3_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband4_pos+half_subband-pass_band_bins)+[2000]+[-1000]*(fft_len-subband4_pos-half_subband-1+pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband0_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband0_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband1_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband1_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_1_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband2_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband2_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_1_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband3_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband3_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_1_0_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband4_pos-half_subband+pass_band_bins)+[2000]+[-1000]*(fft_len-subband4_pos+half_subband-1-pass_band_bins)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband1_pos-1)+[2000]+[-1000]*(half_band*2-subband1_pos)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_2_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband2_pos-1)+[2000]+[-1000]*(half_band*2-subband2_pos)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_2_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband3_pos-1)+[2000]+[-1000]*(half_band*2-subband3_pos)'
    vlen: fft_len
  states: {state: disabled}
- name: blocks_vector_source_x_0_2_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[-1000]*(subband4_pos-1)+[2000]+[-1000]*(half_band*2-subband4_pos)'
    vlen: fft_len
  states: {state: disabled}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: bpf
    type: ccc
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {state: disabled}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    freq_center: '0'
    freq_span: dec0_rate
  states: {state: disabled}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {state: disabled}
- name: fosphor_qt_sink_c_1
  id: fosphor_qt_sink_c
  parameters:
    freq_center: '0'
    freq_span: dec0_rate
    gui_hint: tabs@1:0,0,1,1
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband0_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband1_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband3_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband4_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband_2
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pfb0_chan0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: pfb_rs_ratio
    taps: pfb_rs_taps
    type: ccf
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rs_ratio
    taps: rs_taps
    type: ccf
  states: {state: disabled}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '50'
    ch_map: '[4,5,6,7,0,1,2,3]'
    nchans: round_up_chans
    osr: '1.0'
    taps: pfb_taps
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '50'
    channel: pfbdec0_chan
    decim: pfb_dec
    taps: pfb_taps
  states: {state: disabled}
- name: pfbdec2_wtf
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@1:1,0,1,10
    int_max: '-70'
    int_min: '-90'
    name: '"chan0"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@0:0,0,1,3
    label1: Real
    name: '"Full Spectrum"'
    showports: 'True'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: out_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: dec0_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    label1: '6001'
    name: '"BPF REAL SPECTRUM"'
    showports: 'True'
    type: float
    update_time: '0.001'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    color2: '"cyan"'
    color3: '"blue"'
    color4: '"red"'
    color5: '"dark green"'
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@0:5,0,4,3
    label1: '6001'
    label2: '6002'
    label3: '6003'
    label4: '6004'
    label5: '6005'
    name: '"JAERO CHANNELS"'
    nconnections: '5'
    showports: 'True'
    type: float
    update_time: '0.001'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    color1: '"green"'
    color2: '"cyan"'
    color3: '"magenta"'
    color4: '"magenta"'
    color5: '"magenta"'
    color6: '"green"'
    gui_hint: tabs@0:0,0,1,10
    legend: 'False'
    nconnections: '6'
    update_time: '0.01'
    vlen: fft_len
    x_axis_label: '""'
    x_start: '0'
    x_step: '1.0'
    y_axis_label: '""'
    ymax: '-60'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: '16384'
    gui_hint: tabs@0:2,0,1,10
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: ccc
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from pathlib import Path
      fle = Path('/tmp/cband_hunter_config.conf')
      fle.touch(exist_ok=True)
    section: main_after_init
  states: {state: disabled}
- name: sub_wtf0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,0,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband0"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: sub_wtf1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,2,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband1"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: sub_wtf2
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,4,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband2"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: sub_wtf3
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,6,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband3"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: sub_wtf4
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '2048'
    gui_hint: tabs@0:6,8,2,2
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband4"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: sub_wtf4_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:0,0,1,10
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"subband4"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,12,10
    label0: RF Spectrum
    label1: JAERO CHANNELS
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: vs0
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: vs0
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: vs1_0
  states: {state: disabled}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: vs2_0
  states: {state: disabled}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: vs3_0
  states: {state: disabled}
- name: virtual_source_0_3_0
  id: virtual_source
  parameters:
    stream_id: vs4_0
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9000'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5001
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5002
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5005
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5003
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5004
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_vector_sink_f_0, '5']
- [blocks_add_xx_0_0, '0', qtgui_vector_sink_f_0, '4']
- [blocks_add_xx_0_0_0, '0', qtgui_vector_sink_f_0, '3']
- [blocks_add_xx_0_0_0_0, '0', qtgui_vector_sink_f_0, '2']
- [blocks_add_xx_0_0_0_0_0, '0', qtgui_vector_sink_f_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_real_0_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_complex_to_real_0_2, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_complex_to_real_0_3, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_complex_to_real_0_4, '0', blocks_multiply_const_vxx_0_3, '0']
- [blocks_float_to_short_0, '0', JAERO_zmq_sink_0, '0']
- [blocks_float_to_short_0_0, '0', JAERO_zmq_sink_0_0, '0']
- [blocks_float_to_short_0_1, '0', JAERO_zmq_sink_0_1, '0']
- [blocks_float_to_short_0_2, '0', JAERO_zmq_sink_0_2, '0']
- [blocks_float_to_short_0_3, '0', JAERO_zmq_sink_0_3, '0']
- [blocks_freqshift_cc_0, '0', fft_filter_xxx_0, '0']
- [blocks_freqshift_cc_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_probe_rate_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_short_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0_0_1_0_0_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_float_to_short_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_freq_sink_x_0_0_1_0_0_0, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_float_to_short_0_2, '0']
- [blocks_multiply_const_vxx_0_2, '0', qtgui_freq_sink_x_0_0_1_0_0_0, '3']
- [blocks_multiply_const_vxx_0_3, '0', blocks_float_to_short_0_3, '0']
- [blocks_multiply_const_vxx_0_3, '0', qtgui_freq_sink_x_0_0_1_0_0_0, '4']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_throttle_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_add_xx_0_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_add_xx_0_0_0_0_0, '1']
- [blocks_vector_source_x_0_0_0, '0', blocks_add_xx_0_0_0_0, '1']
- [blocks_vector_source_x_0_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_vector_source_x_0_0_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_vector_source_x_0_0_0_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_vector_source_x_0_1, '0', blocks_add_xx_0_0_0_0_0, '2']
- [blocks_vector_source_x_0_1_0, '0', blocks_add_xx_0_0_0_0, '2']
- [blocks_vector_source_x_0_1_0_0, '0', blocks_add_xx_0_0_0, '2']
- [blocks_vector_source_x_0_1_0_0_0, '0', blocks_add_xx_0_0, '2']
- [blocks_vector_source_x_0_1_0_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_vector_source_x_0_2, '0', blocks_add_xx_0_0_0_0, '0']
- [blocks_vector_source_x_0_2_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_vector_source_x_0_2_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_vector_source_x_0_2_0_0_0, '0', blocks_add_xx_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_real_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', sub_wtf0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', zeromq_pub_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', fosphor_qt_sink_c_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', sub_wtf1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', zeromq_pub_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', sub_wtf3, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', zeromq_pub_sink_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', sub_wtf4, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', zeromq_pub_sink_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', fosphor_glfw_sink_c_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', sub_wtf2, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', zeromq_pub_sink_0_0_1, '0']
- [pfb0_chan0, '0', blocks_freqshift_cc_0, '0']
- [pfb0_chan0, '0', blocks_probe_rate_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0_1, '0']
- [pfb_channelizer_ccf_0, '3', blocks_null_sink_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', pfbdec2_wtf, '0']
- [pfb_channelizer_ccf_0, '3', rational_resampler_xxx_0, '0']
- [pfb_channelizer_ccf_0, '4', blocks_null_sink_0_2, '0']
- [pfb_channelizer_ccf_0, '5', blocks_null_sink_0_0_1, '0']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0_1_0, '0']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0_0_0_0, '0']
- [pfb_decimator_ccf_0, '0', pfb0_chan0, '0']
- [pfb_decimator_ccf_0, '0', pfbdec2_wtf, '0']
- [pfb_decimator_ccf_0, '0', rational_resampler_xxx_0, '0']
- [qtgui_freq_sink, freq, freq_xlating_fir_filter_xxx_0, freq]
- [qtgui_waterfall_sink_x_0, freq, blocks_msgpair_to_var_0, inpair]
- [rational_resampler_xxx_0, '0', blocks_freqshift_cc_0, '0']
- [virtual_source_0, '0', pfb_channelizer_ccf_0, '0']
- [virtual_source_0, '0', pfb_decimator_ccf_0, '0']
- [virtual_source_0, '0', sub_wtf4_0, '0']
- [virtual_source_0_0_0, '0', blocks_complex_to_real_0_1, '0']
- [virtual_source_0_1_0, '0', blocks_complex_to_real_0_2, '0']
- [virtual_source_0_2_0, '0', blocks_complex_to_real_0_3, '0']
- [virtual_source_0_3_0, '0', blocks_complex_to_real_0_4, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_source_0, '0', fosphor_qt_sink_c_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0-rc1
