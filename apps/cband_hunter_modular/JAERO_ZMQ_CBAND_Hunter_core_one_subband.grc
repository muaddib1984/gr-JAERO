options:
  parameters:
    author: muaddib
    description: ZMQ I/Q input, Channelizer and Socket Outputs to JAERO
    generate_options: no_gui
    id: JAERO_ZMQ_CBAND_Hunter_core_one_subband
    output_language: python
    run_options: run
    title: CBAND HUNTER CORE SUBBANDS
  states: {}

blocks:
- name: bin_size
  id: variable
  parameters:
    value: (samp_rate/fft_len)
  states: {}
- name: channel_or_subband
  id: variable_qtgui_chooser
  parameters:
    label: Channel or Subband
    labels: '["channel","subband"]'
    num_opts: '0'
    options: '[i for i in range(2)]'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {state: disabled}
- name: conf_section
  id: variable
  parameters:
    value: '"subband" if channel_or_subband == 1 else "channel"'
  states: {state: disabled}
- name: dec0
  id: variable
  parameters:
    value: n_chans
  states: {}
- name: dec0_rate
  id: variable
  parameters:
    value: xlate_rate/dec0
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: frac_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Center Frequency of 
      your Capture File
    value: 1534e6
  states: {}
- name: freq_write
  id: variable
  parameters:
    comment: |-
      default variable 
      with value needed
    value: '0'
  states: {}
- name: half_band
  id: variable
  parameters:
    value: int(fft_len//2)
  states: {}
- name: half_subband
  id: variable
  parameters:
    value: int(fft_len//n_chans//2)
  states: {}
- name: n_chans
  id: variable
  parameters:
    value: '9'
  states: {}
- name: n_subbands
  id: variable
  parameters:
    value: '5'
  states: {}
- name: nphases
  id: variable
  parameters:
    value: '32'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: pass_band_bins
  id: variable
  parameters:
    value: int(((dec0_rate/2)*0.1)/(samp_rate/fft_len))
  states: {}
- name: rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases, nphases, frac_bw, 0.5-frac_bw)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample Rate of your Capture File
    value: 2.16e6
  states: {}
- name: subband
  id: variable
  parameters:
    value: int(fft_len/n_chans)
  states: {}
- name: subband0_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband0_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband0_pos*bin_size
    writeback: ''
  states: {}
- name: subband0_pos
  id: variable
  parameters:
    value: subband_positions[1]
  states: {}
- name: subband1_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband1_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband1_pos*bin_size
    writeback: ''
  states: {}
- name: subband1_pos
  id: variable
  parameters:
    value: subband_positions[3]-1
  states: {}
- name: subband2_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband2_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+(subband2_pos*bin_size)
    writeback: ''
  states: {}
- name: subband2_pos
  id: variable
  parameters:
    value: subband_positions[5]
  states: {}
- name: subband3_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband3_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband3_pos*bin_size
    writeback: ''
  states: {}
- name: subband3_pos
  id: variable
  parameters:
    value: subband_positions[7]
  states: {}
- name: subband4_offset
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: subband4_offset
    section: subbands
    type: real
    value: (-xlate_rate/2)+subband4_pos*bin_size
    writeback: ''
  states: {}
- name: subband4_pos
  id: variable
  parameters:
    value: subband_positions[9]
  states: {}
- name: subband_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,0,1,1
    type: real
    value: subband0_pos*bin_size
  states: {state: disabled}
- name: subband_1
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,2,1,1
    type: real
    value: subband1_pos*bin_size
  states: {state: disabled}
- name: subband_2
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,4,1,1
    type: real
    value: subband2_offset
  states: {state: disabled}
- name: subband_3
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,6,1,1
    type: real
    value: subband3_pos*bin_size
  states: {state: disabled}
- name: subband_4
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:9,8,1,1
    type: real
    value: subband4_pos*bin_size
  states: {state: disabled}
- name: subband_positions
  id: variable
  parameters:
    value: '[i for i in range(0,fft_len,half_subband*(n_chans//5))]'
  states: {}
- name: subband_write
  id: variable
  parameters:
    value: '"subband_"+str(write_subband_select)'
  states: {state: disabled}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (dec0_rate/2)*0.9
    gain: '1.0'
    samp_rate: xlate_rate
    width: (dec0_rate/2)*0.1
    win: window.WIN_HAMMING
  states: {}
- name: variable_config_0
  id: variable_config
  parameters:
    config_file: /tmp/cband_hunter_config.conf
    option: write_freq_select_var
    section: conf_section
    type: real
    value: '0'
    writeback: freq_write
  states: {state: disabled}
- name: waterfall_max
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,0,1,5
    label: waterfall max
    start: '-200'
    step: '1'
    stop: '0'
    value: '-78'
  states: {state: disabled}
- name: waterfall_min
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,5,1,5
    label: waterfall min
    start: '-200'
    step: '1'
    stop: '0'
    value: '-90'
  states: {state: disabled}
- name: write_freq_select
  id: variable_qtgui_chooser
  parameters:
    label: Write Frequency to Conf
    labels: '[str(i) for i in range(40)]'
    num_opts: '0'
    options: '[i for i in range(40)]'
    type: real
    value: '0'
  states: {state: disabled}
- name: write_freq_select_var
  id: variable
  parameters:
    value: '"freq_"+str(write_freq_select) if channel_or_subband==0 else subband3_pos'
  states: {state: disabled}
- name: write_subband_select
  id: variable_qtgui_chooser
  parameters:
    label: Write Subband Freq to Conf
    labels: '[str(i) for i in range(n_subbands)]'
    num_opts: '0'
    options: '[i for i in range(n_subbands)]'
    type: real
    value: '0'
  states: {state: disabled}
- name: xlate_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband0_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband1_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband3_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband4_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: subband2_offset
    decim: dec0
    samp_rate: xlate_rate
    taps: taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rs_ratio
    taps: rs_taps
    type: ccf
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      from pathlib import Path
      fle = Path('/tmp/cband_hunter_config.conf')
      fle.touch(exist_ok=True)
    section: main_after_init
  states: {state: disabled}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      print("#"*80)
      print("*"*5+"'CBAND HUNTER CORE SUBBANDS' FLOWGRAPH"+"*"*5)
      print("  THIS FLOWGRAPH DIVIDES THE TOTAL BANDWIDTH INTO 5 SUBBANDS. ")
      print("  THEIR POSITION CAN BE ADJUSTED USING THE 'CBAND HUNTER GUI' APP")
      print("#"*80)
    section: main_after_init
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,1,1
    label0: RF Spectrum
    num_tabs: '1'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: vs0
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: vs1
  states: {state: disabled}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '9000'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5001
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5002
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5005
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_pub_sink_0_0_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5003
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0_2
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5004
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_throttle_0, '0', pfb_arb_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', zeromq_pub_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', zeromq_pub_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', virtual_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', zeromq_pub_sink_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', zeromq_pub_sink_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', zeromq_pub_sink_0_0_1, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0-rc1
