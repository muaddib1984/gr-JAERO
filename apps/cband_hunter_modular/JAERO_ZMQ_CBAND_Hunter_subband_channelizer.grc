options:
  parameters:
    author: muaddib
    description: ZMQ I/Q input, Channelizer and Socket Outputs to JAERO
    generate_options: no_gui
    id: JAERO_ZMQ_CBAND_Hunter_subband_channelizer
    output_language: python
    run_options: run
    title: CBAND HUNTER CHANNELIZER
  states: {}

blocks:
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,2
    label: Audio Signal Volume
    start: '0.1'
    step: '0.1'
    stop: '1000'
    value: '100.0'
  states: {state: disabled}
- name: audio_volume
  id: variable
  parameters:
    value: '100.0'
  states: {}
- name: bin_size
  id: variable
  parameters:
    value: (samp_rate/fft_len)
  states: {}
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: (usb_bw)*0.95
    low_cutoff_freq: (usb_bw)*0.05
    samp_rate: out_rate
    type: complex_band_pass
    width: (usb_bw)*0.05
    win: window.WIN_HAMMING
  states: {}
- name: chan_rate
  id: variable
  parameters:
    value: 10.5e3
  states: {}
- name: dec0
  id: variable
  parameters:
    value: n_chans
  states: {}
- name: dec0_rate
  id: variable
  parameters:
    value: xlate_rate/dec0
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: frac_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: frac_bw_0
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Center Frequency of 
      your Capture File
    value: 1534e6
  states: {}
- name: freq_write
  id: variable
  parameters:
    comment: |-
      default variable 
      with value needed
    value: '0'
  states: {}
- name: interp
  id: variable
  parameters:
    value: int(xlate_rate/pfb_rs_rate/n_chans)
  states: {state: disabled}
- name: n_chans
  id: variable
  parameters:
    value: '9'
  states: {}
- name: n_subbands
  id: variable
  parameters:
    value: '5'
  states: {}
- name: nphases
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nphases_0
  id: variable
  parameters:
    value: '32'
  states: {}
- name: out_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: pfb_dec
  id: variable
  parameters:
    value: round_up_chans
  states: {}
- name: pfb_out_rate
  id: variable
  parameters:
    value: dec0_rate/pfb_dec
  states: {}
- name: pfb_rs_rate
  id: variable
  parameters:
    value: out_rate
  states: {}
- name: pfb_rs_ratio
  id: variable
  parameters:
    value: pfb_rs_rate/pfb_out_rate
  states: {}
- name: pfb_rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases_0, nphases_0, frac_bw_0, 0.5-frac_bw_0)
  states: {state: disabled}
- name: pfb_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: ((usb_bw)/2)*.95
    gain: '1.0'
    samp_rate: dec0_rate
    width: ((usb_bw)/2)*.05
    win: window.WIN_HAMMING
  states: {}
- name: ports
  id: variable
  parameters:
    value: '[i for i in range(int(port_start),int(port_start)+15)]'
  states: {}
- name: round_up_chans
  id: variable
  parameters:
    value: int((xlate_rate/n_chans)/usb_bw)
  states: {}
- name: rs_rate
  id: variable
  parameters:
    value: round_up_chans*out_rate
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: rs_rate/samp_rate
  states: {}
- name: rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases, nphases, frac_bw, 0.5-frac_bw)
  states: {state: disabled}
- name: short_scaling
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,0,1,2
    label: JAERO DIGITAL VOLUME
    rangeType: int
    start: '1'
    step: '1'
    stop: '65536'
    value: '32768'
  states: {state: disabled}
- name: short_scaling
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: subband_num
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usb_bw
  id: variable
  parameters:
    value: 15e3
  states: {}
- name: waterfall_max
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,0,1,5
    label: waterfall max
    start: '-200'
    step: '1'
    stop: '0'
    value: '-78'
  states: {state: disabled}
- name: waterfall_min
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:10,5,1,5
    label: waterfall min
    start: '-200'
    step: '1'
    stop: '0'
    value: '-90'
  states: {state: disabled}
- name: wtf_ports
  id: variable
  parameters:
    value: '[i for i in range(int(wtf_port_start),int(wtf_port_start)+15)]'
  states: {}
- name: xlate_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: JAERO_zmq_sink_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[2])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_1
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[9])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[3])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[4])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[5])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_0_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[6])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_0_0_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[13])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_0_0_0_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[14])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_0_1
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[12])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_1
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[1])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_1_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[8])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_0_2
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[11])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_1
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[0])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_1_0
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[7])
    rate: '48000'
    topic: JAERO
  states: {}
- name: JAERO_zmq_sink_0_4_2
  id: JAERO_zmq_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(ports[10])
    rate: '48000'
    topic: JAERO
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: dec0_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '50'
    ch_map: '[i for i in range(int(round_up_chans/2),round_up_chans)]+[i for i in range(0,int(round_up_chans/2))]'
    nchans: round_up_chans
    osr: '1.0'
    taps: pfb_taps
  states: {}
- name: pfb_out_to_jaero_zmq_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_0_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_0_0_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_0_1
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_0_1_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_0_2
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_1
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_1_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_2
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_2_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_3
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_3_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_3_0_0
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfb_out_to_jaero_zmq_0_4
  id: pfb_out_to_jaero_zmq
  parameters:
    audio_rate: 48e3
    audio_volume: audio_volume
    pfb_out_rate: pfb_out_rate
    short_scaling: short_scaling
    usb_bw: usb_bw
  states: {}
- name: pfbdec2_wtf
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,3,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6003/''threethree''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,4,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6004/''fourfour''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,5,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6005/''fivefive''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,6,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6006/''sixsix''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,7,1,1
    int_max: '-70'
    int_min: '-90'
    name: '"ZMQ6007/''sevenseven''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,8,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6008/''eighteight''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,9,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6007/''ninenine''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,11,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6007/''eleven''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,13,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6007/''thirteen''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,14,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6007/''fourteen''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,15,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6007/''fifteen''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,10,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6007/''tenten''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_0_0_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,12,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6007/''twelve''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    gui_hint: tabs@0:1,2,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6002/''twotwo''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:1,1,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    name: '"ZMQ6001/''oneone''"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: pfbdec2_wtf_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@1:1,0,1,1
    int_max: '-70'
    int_min: '-90'
    name: '"ZMQ 6005"'
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: port_start
  id: parameter
  parameters:
    label: JAERO instance port start
    short_id: J
    type: str
    value: '6001'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 2.16e6
  states: {}
- name: sub_wtf4_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,1,1,15
    int_max: waterfall_max
    int_min: waterfall_min
    name: subband
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,2,2
    label0: JAERO LEVEL CONTROL
    num_tabs: '1'
  states: {state: disabled}
- name: wtf_port_start
  id: parameter
  parameters:
    label: GUI zmq port start
    short_id: W
    type: str
    value: '7001'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: xmlrpc_server_port
  states: {}
- name: xmlrpc_server_port
  id: parameter
  parameters:
    label: JAERO instance port start
    short_id: X
    type: intx
    value: '9001'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[0])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[1])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[9])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_1
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[2])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_1_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[10])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_2
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[3])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_2_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[11])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_3
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[4])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_3_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[12])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_4
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[5])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_4_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[13])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_5
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[6])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_5_0
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[14])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_6
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[7])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_pub_sink_0_7
  id: zeromq_pub_sink
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[8])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(zmq_port)
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zmq_port
  id: parameter
  parameters:
    label: ZMQ Port
    short_id: P
    type: intx
    value: '5001'
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_throttle_0, '0', pfb_channelizer_ccf_0, '0']
- [pfb_channelizer_ccf_0, '0', blocks_null_sink_0, '0']
- [pfb_channelizer_ccf_0, '0', pfbdec2_wtf_1, '0']
- [pfb_channelizer_ccf_0, '1', blocks_null_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '1', pfb_out_to_jaero_zmq_0, '0']
- [pfb_channelizer_ccf_0, '1', pfbdec2_wtf_0_1, '0']
- [pfb_channelizer_ccf_0, '1', zeromq_pub_sink_0, '0']
- [pfb_channelizer_ccf_0, '10', pfb_out_to_jaero_zmq_0_1_0, '0']
- [pfb_channelizer_ccf_0, '10', pfbdec2_wtf_0_0_0_0_0_1, '0']
- [pfb_channelizer_ccf_0, '10', zeromq_pub_sink_0_0_0, '0']
- [pfb_channelizer_ccf_0, '11', pfb_out_to_jaero_zmq_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '11', pfbdec2_wtf_0_0_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '11', zeromq_pub_sink_0_1_0, '0']
- [pfb_channelizer_ccf_0, '12', pfb_out_to_jaero_zmq_0_2_0, '0']
- [pfb_channelizer_ccf_0, '12', pfbdec2_wtf_0_0_0_0_0_2, '0']
- [pfb_channelizer_ccf_0, '12', zeromq_pub_sink_0_2_0, '0']
- [pfb_channelizer_ccf_0, '13', pfb_out_to_jaero_zmq_0_0_1_0, '0']
- [pfb_channelizer_ccf_0, '13', pfbdec2_wtf_0_0_0_0_0_0_1, '0']
- [pfb_channelizer_ccf_0, '13', zeromq_pub_sink_0_3_0, '0']
- [pfb_channelizer_ccf_0, '14', pfb_out_to_jaero_zmq_0_3_0, '0']
- [pfb_channelizer_ccf_0, '14', pfbdec2_wtf_0_0_0_0_0_0_1_0, '0']
- [pfb_channelizer_ccf_0, '14', zeromq_pub_sink_0_4_0, '0']
- [pfb_channelizer_ccf_0, '15', pfb_out_to_jaero_zmq_0_3_0_0, '0']
- [pfb_channelizer_ccf_0, '15', pfbdec2_wtf_0_0_0_0_0_0_1_0_0, '0']
- [pfb_channelizer_ccf_0, '15', zeromq_pub_sink_0_5_0, '0']
- [pfb_channelizer_ccf_0, '2', blocks_null_sink_0_1, '0']
- [pfb_channelizer_ccf_0, '2', pfb_out_to_jaero_zmq_0_0, '0']
- [pfb_channelizer_ccf_0, '2', pfbdec2_wtf_0_0_1, '0']
- [pfb_channelizer_ccf_0, '2', zeromq_pub_sink_0_0, '0']
- [pfb_channelizer_ccf_0, '3', blocks_null_sink_0_0_0, '0']
- [pfb_channelizer_ccf_0, '3', pfb_out_to_jaero_zmq_0_1, '0']
- [pfb_channelizer_ccf_0, '3', pfbdec2_wtf, '0']
- [pfb_channelizer_ccf_0, '3', zeromq_pub_sink_0_1, '0']
- [pfb_channelizer_ccf_0, '4', blocks_null_sink_0_2, '0']
- [pfb_channelizer_ccf_0, '4', pfb_out_to_jaero_zmq_0_0_0, '0']
- [pfb_channelizer_ccf_0, '4', pfbdec2_wtf_0, '0']
- [pfb_channelizer_ccf_0, '4', zeromq_pub_sink_0_2, '0']
- [pfb_channelizer_ccf_0, '5', blocks_null_sink_0_0_1, '0']
- [pfb_channelizer_ccf_0, '5', pfb_out_to_jaero_zmq_0_2, '0']
- [pfb_channelizer_ccf_0, '5', pfbdec2_wtf_0_0, '0']
- [pfb_channelizer_ccf_0, '5', zeromq_pub_sink_0_3, '0']
- [pfb_channelizer_ccf_0, '6', blocks_null_sink_0_1_0, '0']
- [pfb_channelizer_ccf_0, '6', pfb_out_to_jaero_zmq_0_0_1, '0']
- [pfb_channelizer_ccf_0, '6', pfbdec2_wtf_0_0_0, '0']
- [pfb_channelizer_ccf_0, '6', zeromq_pub_sink_0_4, '0']
- [pfb_channelizer_ccf_0, '7', blocks_null_sink_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '7', pfb_out_to_jaero_zmq_0_3, '0']
- [pfb_channelizer_ccf_0, '7', pfbdec2_wtf_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '7', zeromq_pub_sink_0_5, '0']
- [pfb_channelizer_ccf_0, '8', pfb_out_to_jaero_zmq_0_4, '0']
- [pfb_channelizer_ccf_0, '8', pfbdec2_wtf_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '8', zeromq_pub_sink_0_6, '0']
- [pfb_channelizer_ccf_0, '9', pfb_out_to_jaero_zmq_0_0_2, '0']
- [pfb_channelizer_ccf_0, '9', pfbdec2_wtf_0_0_0_0_0_0, '0']
- [pfb_channelizer_ccf_0, '9', zeromq_pub_sink_0_7, '0']
- [pfb_out_to_jaero_zmq_0, '0', JAERO_zmq_sink_0_4_1, '0']
- [pfb_out_to_jaero_zmq_0, '0', blocks_probe_rate_0, '0']
- [pfb_out_to_jaero_zmq_0_0, '0', JAERO_zmq_sink_0_4_0_1, '0']
- [pfb_out_to_jaero_zmq_0_0_0, '0', JAERO_zmq_sink_0_4, '0']
- [pfb_out_to_jaero_zmq_0_0_0_0, '0', JAERO_zmq_sink_0_4_2, '0']
- [pfb_out_to_jaero_zmq_0_0_1, '0', JAERO_zmq_sink_0_4_0_0, '0']
- [pfb_out_to_jaero_zmq_0_0_1_0, '0', JAERO_zmq_sink_0_4_0_0_1, '0']
- [pfb_out_to_jaero_zmq_0_0_2, '0', JAERO_zmq_sink_0_4_0_1_0, '0']
- [pfb_out_to_jaero_zmq_0_1, '0', JAERO_zmq_sink_0, '0']
- [pfb_out_to_jaero_zmq_0_1_0, '0', JAERO_zmq_sink_0_1, '0']
- [pfb_out_to_jaero_zmq_0_2, '0', JAERO_zmq_sink_0_4_0, '0']
- [pfb_out_to_jaero_zmq_0_2_0, '0', JAERO_zmq_sink_0_4_0_2, '0']
- [pfb_out_to_jaero_zmq_0_3, '0', JAERO_zmq_sink_0_4_0_0_0, '0']
- [pfb_out_to_jaero_zmq_0_3_0, '0', JAERO_zmq_sink_0_4_0_0_0_0, '0']
- [pfb_out_to_jaero_zmq_0_3_0_0, '0', JAERO_zmq_sink_0_4_0_0_0_0_0, '0']
- [pfb_out_to_jaero_zmq_0_4, '0', JAERO_zmq_sink_0_4_1_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_source_0, '0', sub_wtf4_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0-rc1
