options:
  parameters:
    author: muaddib
    description: ZMQ I/Q input, Channelizer and Socket Outputs to JAERO
    generate_options: qt_gui
    id: JAERO_ZMQ_CBAND_Hunter_subband_channelizer_GUI
    output_language: python
    title: CBAND HUNTER CHANNELIZER GUI
  states: {}

blocks:
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,7
    label: Audio Signal Volume
    start: '0.1'
    step: '0.1'
    stop: '1000'
    value: '100.0'
  states: {}
- name: bin_size
  id: variable
  parameters:
    value: (samp_rate/fft_len)
  states: {}
- name: bpf
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: (usb_bw)*0.95
    low_cutoff_freq: (usb_bw)*0.05
    samp_rate: out_rate
    type: complex_band_pass
    width: (usb_bw)*0.05
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: chan_rate
  id: variable
  parameters:
    value: 10.5e3
  states: {}
- name: dec0
  id: variable
  parameters:
    value: n_chans
  states: {}
- name: dec0_rate
  id: variable
  parameters:
    value: xlate_rate/dec0
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '8192'
  states: {}
- name: frac_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: frac_bw_0
  id: variable
  parameters:
    value: '0.45'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    comment: |-
      Center Frequency of 
      your Capture File
    value: 1534e6
  states: {}
- name: freq_write
  id: variable
  parameters:
    comment: |-
      default variable 
      with value needed
    value: '0'
  states: {}
- name: interp
  id: variable
  parameters:
    value: int(xlate_rate/pfb_rs_rate/n_chans)
  states: {state: disabled}
- name: n_chans
  id: variable
  parameters:
    value: '9'
  states: {}
- name: n_subbands
  id: variable
  parameters:
    value: '5'
  states: {}
- name: nphases
  id: variable
  parameters:
    value: '32'
  states: {}
- name: nphases_0
  id: variable
  parameters:
    value: '32'
  states: {state: disabled}
- name: out_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: pfb_dec
  id: variable
  parameters:
    value: round_up_chans
  states: {}
- name: pfb_out_rate
  id: variable
  parameters:
    value: dec0_rate/pfb_dec
  states: {}
- name: pfb_rs_rate
  id: variable
  parameters:
    value: out_rate
  states: {state: disabled}
- name: pfb_rs_ratio
  id: variable
  parameters:
    value: pfb_rs_rate/pfb_out_rate
  states: {state: disabled}
- name: pfb_rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases_0, nphases_0, frac_bw_0, 0.5-frac_bw_0)
  states: {state: disabled}
- name: ports
  id: variable
  parameters:
    value: '[i for i in range(int(wtf_port_start),int(wtf_port_start)+15)]'
  states: {state: disabled}
- name: round_up_chans
  id: variable
  parameters:
    value: int((xlate_rate/n_chans)/usb_bw)
  states: {}
- name: rs_rate
  id: variable
  parameters:
    value: round_up_chans*out_rate
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: rs_rate/samp_rate
  states: {}
- name: rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases, nphases, frac_bw, 0.5-frac_bw)
  states: {state: disabled}
- name: short_scaling
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,7,1,8
    label: JAERO DIGITAL VOLUME
    rangeType: int
    start: '1'
    step: '1'
    stop: '65536'
    value: '32768'
  states: {}
- name: subband_num
  id: variable
  parameters:
    value: '1'
  states: {}
- name: usb_bw
  id: variable
  parameters:
    value: 15e3
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,1,1,1
    label: '" "'
    type: int
    value: wtf_ports[0]-1000
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,0,1,1
    label: '"ZMQ PORT #"'
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,2,1,1
    label: '" "'
    type: int
    value: wtf_ports[1]-1000
  states: {}
- name: variable_qtgui_label_0_1_0
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,4,1,1
    label: '" "'
    type: int
    value: wtf_ports[3]-1000
  states: {}
- name: variable_qtgui_label_0_1_1
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,6,1,1
    label: '" "'
    type: int
    value: wtf_ports[5]-1000
  states: {}
- name: variable_qtgui_label_0_1_2
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,8,1,1
    label: '" "'
    type: int
    value: wtf_ports[7]-1000
  states: {}
- name: variable_qtgui_label_0_1_3
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,10,1,1
    label: '" "'
    type: int
    value: wtf_ports[9]-1000
  states: {}
- name: variable_qtgui_label_0_1_4
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,12,1,1
    label: '" "'
    type: int
    value: wtf_ports[11]-1000
  states: {}
- name: variable_qtgui_label_0_1_5
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,14,1,1
    label: '" "'
    type: int
    value: wtf_ports[13]-1000
  states: {}
- name: variable_qtgui_label_0_2
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,3,1,1
    label: '" "'
    type: int
    value: wtf_ports[2]-1000
  states: {}
- name: variable_qtgui_label_0_3
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,5,1,1
    label: '" "'
    type: int
    value: wtf_ports[4]-1000
  states: {}
- name: variable_qtgui_label_0_4
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,7,1,1
    label: '" "'
    type: int
    value: wtf_ports[6]-1000
  states: {}
- name: variable_qtgui_label_0_5
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,9,1,1
    label: '" "'
    type: int
    value: wtf_ports[8]-1000
  states: {}
- name: variable_qtgui_label_0_6
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,11,1,1
    label: '" "'
    type: int
    value: wtf_ports[10]-1000
  states: {}
- name: variable_qtgui_label_0_7
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,13,1,1
    label: '" "'
    type: int
    value: wtf_ports[12]-1000
  states: {}
- name: variable_qtgui_label_0_8
  id: variable_qtgui_label
  parameters:
    gui_hint: tabs@0:2,15,1,1
    label: '" "'
    type: int
    value: wtf_ports[14]-1000
  states: {}
- name: waterfall_max
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,7
    label: waterfall max
    start: '-200'
    step: '1'
    stop: '0'
    value: '-78'
  states: {}
- name: waterfall_min
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,7,1,8
    label: waterfall min
    start: '-200'
    step: '1'
    stop: '0'
    value: '-90'
  states: {}
- name: wtf_ports
  id: variable
  parameters:
    value: '[i for i in range(int(wtf_port_start),int(wtf_port_start)+15)]'
  states: {}
- name: xlate_rate
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: dec0_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: pfbdec2_wtf
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,3,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,4,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,5,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,6,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,7,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,8,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,9,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,11,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,13,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0_0_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,14,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0_0_1_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,15,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,10,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_0_0_0_2
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,12,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,2,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: pfbdec2_wtf_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: pfb_out_rate
    color1: '1'
    fc: '0'
    fftsize: '256'
    grid: 'True'
    gui_hint: tabs@0:3,1,1,1
    int_max: waterfall_max
    int_min: waterfall_min
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: port_start
  id: parameter
  parameters:
    label: JAERO instance port start
    short_id: J
    type: str
    value: '6001'
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 2.16e6
  states: {}
- name: sub_wtf4_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: dec0_rate
    color1: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,1,1,15
    int_max: waterfall_max
    int_min: waterfall_min
    name: subband
    showports: 'True'
    type: complex
    update_time: '0.01'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 2,0,12,15
    label0: RF Spectrum
    num_tabs: '1'
  states: {}
- name: wtf_port_start
  id: parameter
  parameters:
    label: GUI zmq port start
    short_id: W
    type: str
    value: '7001'
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_audio_volume
    port: '9001'
    variable: audio_volume
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(zmq_port)
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[0])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[1])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[3])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[4])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_0_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[6])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_0_0_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[10])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_0_0_1
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[14])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_0_1
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[8])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_0_2
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[12])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_1
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[5])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_1_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[7])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_1_0_0
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[11])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_1_1
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[9])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_0_0_1_2
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[13])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0_0_1
  id: zeromq_sub_source
  parameters:
    address: str("tcp://127.0.0.1:")+str(wtf_ports[2])
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}
- name: zmq_port
  id: parameter
  parameters:
    label: ZMQ Port
    short_id: P
    type: intx
    value: '5001'
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_1, print]
- [blocks_throttle_0, '0', sub_wtf4_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_source_0_0, '0', blocks_probe_rate_0, '0']
- [zeromq_sub_source_0_0, '0', pfbdec2_wtf_0_1, '0']
- [zeromq_sub_source_0_0_0, '0', pfbdec2_wtf_0_0_1, '0']
- [zeromq_sub_source_0_0_0_0, '0', pfbdec2_wtf_0, '0']
- [zeromq_sub_source_0_0_0_0_0, '0', pfbdec2_wtf_0_0, '0']
- [zeromq_sub_source_0_0_0_0_0_0, '0', pfbdec2_wtf_0_0_0_0, '0']
- [zeromq_sub_source_0_0_0_0_0_0_0, '0', pfbdec2_wtf_0_0_0_0_0_0_0, '0']
- [zeromq_sub_source_0_0_0_0_0_0_1, '0', pfbdec2_wtf_0_0_0_0_0_0_1_0_0, '0']
- [zeromq_sub_source_0_0_0_0_0_1, '0', pfbdec2_wtf_0_0_0_0_0_0, '0']
- [zeromq_sub_source_0_0_0_0_0_2, '0', pfbdec2_wtf_0_0_0_0_0_0_1, '0']
- [zeromq_sub_source_0_0_0_0_1, '0', pfbdec2_wtf_0_0_0, '0']
- [zeromq_sub_source_0_0_0_0_1_0, '0', pfbdec2_wtf_0_0_0_0_0, '0']
- [zeromq_sub_source_0_0_0_0_1_0_0, '0', pfbdec2_wtf_0_0_0_0_0_2, '0']
- [zeromq_sub_source_0_0_0_0_1_1, '0', pfbdec2_wtf_0_0_0_0_0_1, '0']
- [zeromq_sub_source_0_0_0_0_1_2, '0', pfbdec2_wtf_0_0_0_0_0_0_1_0, '0']
- [zeromq_sub_source_0_0_1, '0', pfbdec2_wtf, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0-rc1
