options:
  parameters:
    author: muaddib
    description: Upper SIdeband AM Demodulator with ZMQ Output to feed JAERO
    generate_options: qt_gui
    id: JAERO_SDRPLAY_BIAS_demod_to_zmq
    output_language: python
    title: JAERO to ZMQ
  states: {}

blocks:
- name: LO_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    label: LO Freq
    orient: Qt.Horizontal
    start: '0'
    step: '10'
    stop: 48e3
    value: '900'
  states: {}
- name: audio_lpf
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,1,1,1
    label: Audio LPF
    orient: Qt.Horizontal
    start: '600'
    step: '100'
    stop: (audio_rate/2)
    value: (audio_rate/2)
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,3,1,1
    label: Audio Volume
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.1'
    stop: '10.0'
    value: '0.9'
  states: {}
- name: dec0
  id: variable
  parameters:
    value: 10 if (samp_rate/10) >= 50000 else 5 if (samp_rate/5) >=50000 else 2 if (samp_rate/2) >=50000 else 1
  states: {}
- name: dec0_rate
  id: variable
  parameters:
    value: samp_rate/dec0
  states: {}
- name: dec1
  id: variable
  parameters:
    value: 10 if (dec0_rate/10) >= 48000 else 5 if (dec0_rate/5) >= 48000 else 2 if (dec0_rate/2) >= 48000 else 1
  states: {}
- name: dec1_rate
  id: variable
  parameters:
    value: (samp_rate/dec0)/dec1
  states: {}
- name: frac_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0,1,1
    label: SDR Center Frequency
    orient: Qt.Horizontal
    start: 52e6
    step: '100'
    stop: 2200e6
    value: 1545e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1,1,1
    label: SDR RF Gain
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.1'
    stop: '49.6'
    value: '32.8'
  states: {}
- name: lpf
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,1,1,1
    label: Channel LPF
    orient: Qt.Horizontal
    start: '300'
    step: '100'
    stop: (dec1_rate/2)*.8
    value: (dec1_rate/2)*.8
  states: {}
- name: lpf_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,3,1,1
    label: Post VFO Low Pass
    orient: Qt.Horizontal
    start: '300'
    step: '100'
    stop: (rs_rate/2)
    value: (rs_rate/2)
  states: {}
- name: lpf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,1
    label: Post VFO Low Pass Gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: nphases
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rs_rate
  id: variable
  parameters:
    value: ((audio_rate)/dec1_rate)*dec1_rate
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: audio_rate/dec1_rate
  states: {}
- name: rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases, nphases, frac_bw, 0.5-frac_bw)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample Rate of your Capture File
    value: 8000e3
  states: {}
- name: shift
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    label: Freq Shift
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: ssb
  id: variable_qtgui_check_box
  parameters:
    'false': '1'
    gui_hint: 6,0,1,1
    label: Checked=Upper Unchecked=Lower
    'true': '-1'
    type: int
    value: '-1'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: ((dec0_rate)/2)*.8
    gain: '1.0'
    samp_rate: samp_rate
    width: ((dec0_rate)/2)*.2
    win: firdes.WIN_HAMMING
  states: {}
- name: JAERO_USB_demod_0
  id: JAERO_USB_demod
  parameters:
    LO_freq: LO_freq
    audio_lpf: audio_lpf*.8
    audio_rate: audio_rate
    lpf_freq: lpf_freq*.8
    lpf_gain: lpf_gain
    ssb: ssb
    volume: audio_volume
  states: {}
- name: JAERO_zmq_sink_0
  id: JAERO_zmq_sink
  parameters:
    address: tcp://127.0.0.1:6001
    rate: '48000.0'
    topic: JAERO
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: shift
    decim: dec0
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf
    decim: dec1
    gain: '1.0'
    samp_rate: samp_rate/dec0
    type: fir_filter_ccf
    width: (dec1_rate/2)*.2
    win: firdes.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rs_ratio
    taps: rs_taps
    type: ccf
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,0,1,2
    label1: Real
    name: '"Full Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: dec1_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,0,1,1
    name: '"Complex"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: rs_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,1,1,1
    label1: Real
    label2: Imag
    name: '"Complex to Real/Imag"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rs_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,2,1,1
    label1: Real
    label2: Imag
    name: '"BFO Shifted Real/Imag"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: dec0_rate
    fc: 1555622487+shift
    fftsize: '4096'
    grid: 'True'
    gui_hint: 0,2,1,2
    label1: Real
    name: '"Shifted Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: rs_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 4,3,1,1
    label1: Real
    name: '"Signal to JAERO"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    agc0: 'False'
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: sdrplay
    overall_gain0: gain
    samp_rate: samp_rate
    sdrplay_agc_setpoint: '-30'
    sdrplay_biastee: 'True'
    sdrplay_dabnotch: 'False'
    sdrplay_if_mode: Zero-IF
    sdrplay_rfnotch: 'False'
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: real
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: imag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: real
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: imag
  states: {}

connections:
- [JAERO_USB_demod_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [JAERO_USB_demod_0, '1', qtgui_freq_sink_x_0_0_1_0, '1']
- [JAERO_USB_demod_0, '2', JAERO_zmq_sink_0, '0']
- [JAERO_USB_demod_0, '3', qtgui_freq_sink_x_0_0_1_0_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_complex_to_float_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_0_0_1, '1']
- [blocks_complex_to_float_0, '1', virtual_sink_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0_1_0_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [soapy_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_source_0, '0', qtgui_freq_sink, '0']
- [virtual_source_0, '0', JAERO_USB_demod_0, '0']
- [virtual_source_0_0, '0', JAERO_USB_demod_0, '1']

metadata:
  file_format: 1
