options:
  parameters:
    author: muaddib
    description: Upper SIdeband AM Demodulator with ZMQ Output to feed JAERO
    generate_options: qt_gui
    id: JAERO_ZMQ_demod_to_zmq_dev
    output_language: python
    title: JAERO to ZMQ
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:2,3,1,1
    label: Audio Signal Volume
    start: '0.1'
    step: '0.1'
    stop: '100.0'
    value: '5.0'
  states: {}
- name: dec0
  id: variable
  parameters:
    value: 20 if samp_rate >= 480000 else 5 if samp_rate >=50000 else 1
  states: {}
- name: dec0_rate
  id: variable
  parameters:
    value: samp_rate/dec0
  states: {}
- name: dec1
  id: variable
  parameters:
    value: 4 if dec0_rate > 480000 else 1
  states: {}
- name: dec1_rate
  id: variable
  parameters:
    value: (samp_rate/dec0)/dec1
  states: {}
- name: frac_bw
  id: variable
  parameters:
    value: '0.45'
  states: {}
- name: freq
  id: variable
  parameters:
    comment: |-
      Center Frequency of 
      your Capture File
    value: '1555622487'
  states: {}
- name: lpf
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:3,3,1,1
    label: Pass-Band Cutoff
    start: (dec0_rate/2)*0.05
    step: '100'
    stop: (audio_rate/2)*.95
    value: (audio_rate/2)*.95
  states: {}
- name: nphases
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pass_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    label: Pass-Band Width
    start: '600'
    step: '100'
    stop: (dec1_rate/2)*.8
    value: (dec1_rate/2)*.8
  states: {state: disabled}
- name: rs_rate
  id: variable
  parameters:
    value: ((audio_rate)/dec1_rate)*dec1_rate
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: audio_rate/dec1_rate
  states: {}
- name: rs_taps
  id: variable
  parameters:
    value: firdes.low_pass(nphases, nphases, frac_bw, 0.5-frac_bw)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: Sample Rate of your Capture File
    value: 2e6
  states: {}
- name: shift
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:4,3,1,1
    label: Freq Shift
    start: '-samp_rate/2'
    step: '100'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: short_scaling
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,3,1,1
    label: JAERO DIGITAL VOLUME
    rangeType: int
    start: '1'
    step: '1'
    stop: '65536'
    value: '32768'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: ((dec0_rate)/2)*.8
    gain: '1.0'
    samp_rate: samp_rate
    width: ((dec0_rate)/2)*.2
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: (dec0_rate/2)*0.9
    low_cutoff_freq: (dec0_rate/2)*0.1
    samp_rate: samp_rate
    type: complex_band_pass
    width: (dec0_rate/2)*0.1
    win: window.WIN_HAMMING
  states: {}
- name: JAERO_zmq_sink_0
  id: JAERO_zmq_sink
  parameters:
    address: tcp://127.0.0.1:6001
    rate: '48000.0'
    topic: JAERO
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: dec1
    gain: '1'
    high_cutoff_freq: bpf_fc
    low_cutoff_freq: bpf_fc
    samp_rate: dec0_rate
    type: fir_filter_ccc
    width: (bpf_fc+pass_bandwidth)*.2
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: short_scaling
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume
    type: float
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.1'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: shift
    decim: dec0
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: lpf
    decim: dec1
    gain: '1.0'
    samp_rate: samp_rate/dec0
    type: fir_filter_ccf
    width: (dec1_rate/2)*.1
    win: window.WIN_HAMMING
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: rs_ratio
    taps: rs_taps
    type: ccf
  states: {}
- name: qtgui_freq_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: tabs@0:0,0,1,3
    label1: Real
    name: '"Full Spectrum"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: dec0_rate
    fc: freq
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@0:1,0,4,3
    label1: Real
    name: '"Sideband Spectrum"'
    type: float
    update_time: '0.001'
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rs_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@0:0,3,1,1
    label1: Real
    name: '"Signal to JAERO"'
    type: float
    update_time: '0.00001'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,5,4
    label0: MAIN
    num_tabs: '1'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [band_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_freq_sink_x_0_0_1_0_0, '0']
- [blocks_float_to_short_0, '0', JAERO_zmq_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0_1_0_1_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', band_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_real_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', pfb_arb_resampler_xxx_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_probe_rate_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink, '0']

metadata:
  file_format: 1
